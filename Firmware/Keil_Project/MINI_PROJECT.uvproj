# Keil uVision project MINI_PROJECT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: MINI_PROJECT +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    ../Source/ADC/: adc.c
    ../Source/Delay/: delay.c
    ../Source/Interrupt/: eint0_irq.c
    ../Source/Keypad/: kpm.c
    ../Source/LCD/: lcd.c lcd_startup.c
    ../Source/LDR/: ldr.c
    ../Source/GPIO/: led_symbol.c
    ../Source/Pin_Configuration/: pin_connect_block.c
    ../Source/RTC/: rtc.c rtc_menu.c
    ../Source/Main/: streetlight_main.c
    ../Source/Scheduling/: time_window.c
