# Keil uVision project MINI_PROJECT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: MINI_PROJECT +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    ./Adaptive-Streetlight-Automation_with folders/: adc.c delay.c eint0_irq.c kpm.c lcd.c lcd_startup.c ldr.c led_symbol.c pin_connect_block.c rtc.c rtc_menu.c streetlight_main.c time_window.c
